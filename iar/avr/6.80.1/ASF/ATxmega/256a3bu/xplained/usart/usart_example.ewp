# IAR project usart_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.IExtraOptions: --no_path_in_file_macros
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; xmega/drivers/pmic; ../../common/xmega/drivers/pmic; common/services/clock; ../../common/common/services/clock; common/services/gpio; ../../common/common/services/gpio; xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained; ../../common/xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained; common/boards; ../../common/common/boards; common/services/ioport; ../../common/common/services/ioport; xmega/utils; ../../common/xmega/utils; xmega/boards/xmega_a3bu_xplained; ../../common/xmega/boards/xmega_a3bu_xplained; xmega/utils/preprocessor; ../../common/xmega/utils/preprocessor; xmega/drivers/usart; ../../common/xmega/drivers/usart; xmega/boards; ../../common/xmega/boards; xmega/drivers/nvm; ../../common/xmega/drivers/nvm; common/utils; ../../common/common/utils; xmega/drivers/cpu; ../../common/xmega/drivers/cpu; xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained/iar; ../../common/xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained/iar
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/boards
    ../../common/common/boards/: board.h
  group common/services/clock
    common/services/clock/: genclk.h
    ../../common/common/services/clock/: osc.h pll.h sysclk.h
  group common/services/clock/xmega
    ../../common/common/services/clock/xmega/: osc.h pll.h sysclk.c sysclk.h
  group common/services/gpio
    ../../common/common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../common/common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/ioport
    ../../common/common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../common/common/services/ioport/xmega/: ioport.h ioport_compat.c ioport_compat.h
  group common/utils
    ../../common/common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../common/common/utils/interrupt/: interrupt_avr8.h
  group xmega/boards/xmega_a3bu_xplained
    ../../common/xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/drivers/cpu
    ../../common/xmega/drivers/cpu/: ccp.h ccp.s xmega_reset_cause.h
  group xmega/drivers/nvm
    ../../common/xmega/drivers/nvm/: nvm.c nvm.h nvm_asm.s
  group xmega/drivers/pmic
    ../../common/xmega/drivers/pmic/: pmic.h
  group xmega/drivers/usart
    ../../common/xmega/drivers/usart/: usart.c usart.h
  group xmega/drivers/usart/example
    xmega/drivers/usart/example/: usart_example.c
  group xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained
    xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained/: conf_board.h conf_clock.h conf_usart_example.h
  group xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained/iar
    xmega/drivers/usart/example/atxmega256a3bu_xmega_a3bu_xplained/iar/: asf.h
  group xmega/utils
    ../../common/xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/assembler
    ../../common/xmega/utils/assembler/: iar.h
  group xmega/utils/bit_handling
    ../../common/xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../common/xmega/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h

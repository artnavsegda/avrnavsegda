# IAR project usb.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ASF/common/boards; ASF/common/services/clock; ASF/common/services/delay; ASF/common/services/gpio; ASF/common/services/serial; ASF/common/services/sleepmgr; ASF/common/services/spi; ASF/common/services/ioport; ASF/common/services/twi; ASF/common/services/usb; ASF/common/services/usb/udc; ASF/common/services/usb/class/vendor; ASF/common/services/usb/class/vendor/device; ASF/common/utils; ASF/common/utils/stdio/stdio_serial; ASF/xmega/boards; ASF/xmega/utils; ASF/xmega/utils/preprocessor; ASF/xmega/boards/xmega_a3bu_xplained; ASF/xmega/drivers/adc; ASF/xmega/drivers/cpu; ASF/xmega/drivers/nvm; ASF/xmega/drivers/pmic; ASF/xmega/drivers/sleep; ASF/xmega/drivers/spi; ASF/xmega/drivers/tc; ASF/xmega/drivers/twi; ASF/xmega/drivers/usart; ASF/xmega/drivers/usb; config; $PROJ_DIR$
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm256a3bu.xcl
  group (top)
    ./: asf.h main.c main.h
  group ASF/common/boards
    ASF/common/boards/: board.h
  group ASF/common/services/clock
    ASF/common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group ASF/common/services/clock/xmega
    ASF/common/services/clock/xmega/: osc.h pll.h sysclk.c sysclk.h
  group ASF/common/services/delay
    ASF/common/services/delay/: delay.h
  group ASF/common/services/delay/xmega
    ASF/common/services/delay/xmega/: cycle_counter.h
  group ASF/common/services/gpio
    ASF/common/services/gpio/: gpio.h
  group ASF/common/services/gpio/xmega_gpio
    ASF/common/services/gpio/xmega_gpio/: xmega_gpio.h
  group ASF/common/services/ioport
    ASF/common/services/ioport/: ioport.h
  group ASF/common/services/ioport/xmega
    ASF/common/services/ioport/xmega/: ioport.h ioport_compat.c ioport_compat.h
  group ASF/common/services/serial
    ASF/common/services/serial/: serial.h usart_serial.c
  group ASF/common/services/serial/xmega_usart
    ASF/common/services/serial/xmega_usart/: usart_serial.h
  group ASF/common/services/sleepmgr
    ASF/common/services/sleepmgr/: sleepmgr.h
  group ASF/common/services/sleepmgr/xmega
    ASF/common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group ASF/common/services/spi
    ASF/common/services/spi/: spi_master.h
  group ASF/common/services/spi/xmega_spi
    ASF/common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group ASF/common/services/twi
    ASF/common/services/twi/: twi_master.h twi_slave.h
  group ASF/common/services/twi/xmega_twi
    ASF/common/services/twi/xmega_twi/: twi_master.h twi_slave.h
  group ASF/common/services/usb
    ASF/common/services/usb/: usb_atmel.h usb_protocol.h
  group ASF/common/services/usb/class/vendor
    ASF/common/services/usb/class/vendor/: usb_protocol_vendor.h
  group ASF/common/services/usb/class/vendor/device
    ASF/common/services/usb/class/vendor/device/: udi_vendor.c udi_vendor.h udi_vendor_conf.h udi_vendor_desc.c
  group ASF/common/services/usb/udc
    ASF/common/services/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group ASF/common/utils
    ASF/common/utils/: interrupt.h parts.h
  group ASF/common/utils/interrupt
    ASF/common/utils/interrupt/: interrupt_avr8.h
  group ASF/common/utils/make
    ASF/common/utils/make/: Makefile.avr.in
  group ASF/common/utils/stdio
    ASF/common/utils/stdio/: read.c write.c
  group ASF/common/utils/stdio/stdio_serial
    ASF/common/utils/stdio/stdio_serial/: stdio_serial.h
  group ASF/xmega/boards/xmega_a3bu_xplained
    ASF/xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group ASF/xmega/drivers/adc
    ASF/xmega/drivers/adc/: adc.c adc.h
  group ASF/xmega/drivers/adc/xmega_aau
    ASF/xmega/drivers/adc/xmega_aau/: adc_aau.c
  group ASF/xmega/drivers/cpu
    ASF/xmega/drivers/cpu/: ccp.h ccp.s xmega_reset_cause.h
  group ASF/xmega/drivers/nvm
    ASF/xmega/drivers/nvm/: nvm.c nvm.h nvm_asm.s
  group ASF/xmega/drivers/pmic
    ASF/xmega/drivers/pmic/: pmic.h
  group ASF/xmega/drivers/sleep
    ASF/xmega/drivers/sleep/: sleep.h
  group ASF/xmega/drivers/spi
    ASF/xmega/drivers/spi/: spi.c spi.h
  group ASF/xmega/drivers/tc
    ASF/xmega/drivers/tc/: tc.c tc.h
  group ASF/xmega/drivers/twi
    ASF/xmega/drivers/twi/: twi_common.h twim.c twim.h
  group ASF/xmega/drivers/usart
    ASF/xmega/drivers/usart/: usart.c usart.h
  group ASF/xmega/drivers/usb
    ASF/xmega/drivers/usb/: usb_device.c usb_device.h
  group ASF/xmega/utils
    ASF/xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group ASF/xmega/utils/assembler
    ASF/xmega/utils/assembler/: gas.h
  group ASF/xmega/utils/bit_handling
    ASF/xmega/utils/bit_handling/: clz_ctz.h
  group ASF/xmega/utils/preprocessor
    ASF/xmega/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group config
    config/: conf_adc.h conf_board.h conf_clock.h conf_sleepmgr.h conf_spi_master.h conf_twim.h conf_usart_serial.h
